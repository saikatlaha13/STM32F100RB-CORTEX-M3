# Keil uVision project DAC_M3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DAC_M3 +hex
  c flags: Optim=1
  c define: STM32F10X_MD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f10x_md_vl.s stm32f10x.h system_stm32f10x.c DAC_m3_1.c
